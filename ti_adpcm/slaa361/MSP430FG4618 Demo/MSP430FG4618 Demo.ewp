# IAR project MSP430FG4618 Demo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430FG4618 MSP430FG4618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FG4619.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: ADPCM.C Adpcm.h MSP430FG4618 Demo.c
