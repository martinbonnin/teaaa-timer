<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>C:\MSP430\4492\Bug List\Bugs_validation.ewp</path>
  </project>
  <batchBuild/>
</workspace>


