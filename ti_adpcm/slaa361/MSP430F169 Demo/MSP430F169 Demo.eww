<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>C:\MSP430\Application Reports\ADPCM\Rev 1\ADPCM-associated Code\MSP430FG4619 Demo\MSP430FG4619 Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


